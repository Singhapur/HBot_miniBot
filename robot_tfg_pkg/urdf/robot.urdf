Commit message: Modify for solve radar laser issues and change rader range to 4m

File: robot_tfg_pkg/urdf/robot.urdf (robot description, URDF)
Before this commit: robot mi_robot_tfg, 3 links, 2 joints
Joints:
- joint joint_laser: origin xyz=-0.10 0.0 0.00 rpy=0 0 0 -> xyz=-0.05 0.0 0.00 rpy=0 0 0
